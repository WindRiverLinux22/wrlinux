# This file is generated automatically by wry
SYSTEMD_INC_WRLINUX = ""
SYSTEMD_INC_WRLINUX:osv-wrlinux = "systemd_wrlinux.inc"
require ${SYSTEMD_INC_WRLINUX}
