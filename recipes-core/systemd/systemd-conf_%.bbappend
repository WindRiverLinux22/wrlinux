# This file is generated automatically by wry
SYSTEMD_CONF_INC_WRLINUX = ""
SYSTEMD_CONF_INC_WRLINUX:osv-wrlinux = "systemd-conf_wrlinux.inc"
require ${SYSTEMD_CONF_INC_WRLINUX}
