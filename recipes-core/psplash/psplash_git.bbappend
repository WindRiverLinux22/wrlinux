# This file is generated automatically by wry
PSPLASH_INC_WRLINUX = ""
PSPLASH_INC_WRLINUX:osv-wrlinux = "psplash_wrlinux.inc"
require ${PSPLASH_INC_WRLINUX}
