# This file is generated automatically by wry
SYSVINIT_INITTAB_INC_WRLINUX = ""
SYSVINIT_INITTAB_INC_WRLINUX:osv-wrlinux = "sysvinit-inittab_wrlinux.inc"
require ${SYSVINIT_INITTAB_INC_WRLINUX}
