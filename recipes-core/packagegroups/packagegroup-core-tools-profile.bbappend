# This file is generated automatically by wry
PACKAGEGROUP_CORE_TOOLS_PROFIL_INC_WRLINUX = ""
PACKAGEGROUP_CORE_TOOLS_PROFIL_INC_WRLINUX:osv-wrlinux = "packagegroup-core-tools-profil_wrlinux.inc"
require ${PACKAGEGROUP_CORE_TOOLS_PROFIL_INC_WRLINUX}
