require linux-yocto-wrlinux.inc
include srcrev.inc
require linux-yocto-dev-extra-kernel-src.inc
require extra-kernel-src.inc
