OVP_INCLUDE = ""
OVP_INCLUDE:wrlinux-ovp = "qemu-ovp.inc"

require ${OVP_INCLUDE}
