require recipes-devtools/gcc8/gcc-${PV}.inc
require gcc-cross-canadian.inc
