require recipes-devtools/gcc8/gcc-${PV}.inc
require recipes-devtools/gcc8/gcc-source.inc

EXCLUDE_FROM_WORLD = "1"
