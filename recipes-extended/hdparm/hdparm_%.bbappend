# This file is generated automatically by wry
HDPARM_INC_WRLINUX = ""
HDPARM_INC_WRLINUX:osv-wrlinux = "hdparm_wrlinux.inc"
require ${HDPARM_INC_WRLINUX}
