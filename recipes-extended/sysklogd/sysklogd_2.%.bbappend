# This file is generated automatically by wry
SYSKLOGD_INC_WRLINUX = ""
SYSKLOGD_INC_WRLINUX:osv-wrlinux = "sysklogd_wrlinux.inc"
require ${SYSKLOGD_INC_WRLINUX}
