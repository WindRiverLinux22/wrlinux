CURL_INC_WRLINUX = ""
CURL_INC_WRLINUX_osv-wrlinux = "curl_wrlinux.inc"
require ${CURL_INC_WRLINUX}
