LIBGIT2_INC_WRLINUX = ""
LIBGIT2_INC_WRLINUX:osv-wrlinux = "libgit2_wrlinux.inc"
require ${LIBGIT2_INC_WRLINUX}
