# This file is generated automatically by wry
MARIADB_INC_WRLINUX = ""
MARIADB_INC_WRLINUX:osv-wrlinux = "mariadb_wrlinux.inc"
require ${MARIADB_INC_WRLINUX}
