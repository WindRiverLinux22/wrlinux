# This file is generated automatically by wry
MAILX_INC_WRLINUX = ""
MAILX_INC_WRLINUX:osv-wrlinux = "mailx_wrlinux.inc"
require ${MAILX_INC_WRLINUX}
