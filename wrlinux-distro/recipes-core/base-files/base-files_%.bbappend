# This file is generated automatically by wry
BASE_FILES_INC_WRLINUX = ""
BASE_FILES_INC_WRLINUX:osv-wrlinux = "base-files_wrlinux.inc"
require ${BASE_FILES_INC_WRLINUX}
