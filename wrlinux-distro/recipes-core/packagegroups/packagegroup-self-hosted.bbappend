# This file is generated automatically by wry
PACKAGEGROUP_SELF_HOST_INC_WRLINUX = ""
PACKAGEGROUP_SELF_HOST_INC_WRLINUX:osv-wrlinux = "packagegroup-self-host_wrlinux.inc"
require ${PACKAGEGROUP_SELF_HOST_INC_WRLINUX}
