# This file is generated automatically by wry
PACKAGEGROUP_CORE_BOOT_INC_WRLINUX = ""
PACKAGEGROUP_CORE_BOOT_INC_WRLINUX:osv-wrlinux = "packagegroup-core-boot_wrlinux.inc"
PACKAGEGROUP_CORE_BOOT_INC_WRLINUX:remove_nodistro = "packagegroup-core-boot_wrlinux.inc"
PACKAGEGROUP_CORE_BOOT_INC_WRLINUX:remove_wrlinux-overc = "packagegroup-core-boot_wrlinux.inc"
require ${PACKAGEGROUP_CORE_BOOT_INC_WRLINUX}
