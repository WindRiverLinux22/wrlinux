# This file is generated automatically by wry
BUILDTOOLS = "buildtools"
BUILDTOOLS_TARBALL_INC_WRLINUX = ""
BUILDTOOLS_TARBALL_INC_WRLINUX:osv-wrlinux = "buildtools-tarball_wrlinux.inc"
BUILDTOOLS_TARBALL_INC_WRLINUX:remove_nodistro = "buildtools-tarball_wrlinux.inc"
require ${BUILDTOOLS_TARBALL_INC_WRLINUX}
