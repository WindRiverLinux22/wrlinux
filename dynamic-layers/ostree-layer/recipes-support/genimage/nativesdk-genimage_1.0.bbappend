GENIMAGE_INC_WRLINUX = ""
GENIMAGE_INC_WRLINUX:osv-wrlinux = "genimage_wrlinux.inc"
require ${GENIMAGE_INC_WRLINUX}
