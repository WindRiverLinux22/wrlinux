GENIMAGE_INC_WRLINUX = ""
GENIMAGE_INC_WRLINUX_osv-wrlinux = "genimage_wrlinux.inc"
require ${GENIMAGE_INC_WRLINUX}
