# This file is generated automatically by wry
CONNMAN_INC_WRLINUX = ""
CONNMAN_INC_WRLINUX:osv-wrlinux = "connman_wrlinux.inc"
require ${CONNMAN_INC_WRLINUX}
