# This file is generated automatically by wry
NFS_UTILS_INC_WRLINUX = ""
NFS_UTILS_INC_WRLINUX:osv-wrlinux = "nfs-utils_wrlinux.inc"
require ${NFS_UTILS_INC_WRLINUX}
